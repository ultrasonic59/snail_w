# Keil uVision project usb_cdc_video.uvproj, settings and files
target Product (5060960::V5.06 update 7 (build 960)::ARMCC)
  device: ARM9E-S (Little Endian) ARM
  cpu: CLOCK(60000000) CPUTYPE(ARM9E)
  output: spl-separated
  AfterMake: fromelf --bincombined --output="$Poutput\@L.bin" !L
  AfterMake: $Poutput\postscript.bat @L.bin
  c flags: Optim=1 oTime=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1
  c define: PCB_TINY200V1 CFG_TUSB_MCU=OPT_MCU_F1C100S CFG_TUSB_OS=OPT_OS_RTX4
  c include: .\users\include;.\..\machine\include;.\..\periph\include;.\..\include;.\..\emwin\Include;.\..\tinyusb\src;.\..\tinyusb\hw;.\..\display;.\..\lib\display_gfx;.\..\lib\printf
  asm define: PCB_TINY200V1
  scatter file: .\..\system\ldscript.sct
  link misc: --datacompressor=on
  group Machine
    ./../machine/: f1c100s-intc.c sys-uart.c
    ../machine/: f1c100s-uart.c
  group System
    ./../system/: startup_F1C100s.s spl.s uboot.s mmu_a.s mmu_c.c Retarget.c ubox_a.s target_F1C100s.c RTX_Conf_F1C100s.c efx_main.c
  group Peripheral
    ./../periph/: clk-f1c100s-pll.c fb-f1c100s.c gpio-f1c100s.c pwm-f1c100s.c reset-f1c100s.c
    ../periph/: f1c100s_tvd.c f1c100s_clock.c f1c100s_de.c f1c100s_tve.c f1c100s_gpio.c f1c100s_pwm.c tvd_dev.c tvd_phy.c
  group Users Code
    ./users/: usrentry.c usb_desc.c lcd_task.c video_task.c misc.c misc.h
  group TinyUSB
    ./../tinyusb/src/: tusb.c
    ./../tinyusb/src/device/: usbd_control.c usbd.c
    ./../tinyusb/src/common/: tusb_fifo.c
    ./../tinyusb/src/portable/sunxi/: dcd_sunxi_musb.c
    ../tinyusb/src/class/cdc/: cdc_device.c
    ../tinyusb/src/class/video/: video_device.c video.h video_device.h
  group display
    ../display/: display.c
  group lib
    ../lib/display_gfx/: lcd.c lcd_font.c
  group printf
    ../lib/printf/: printf.c
