# IAR project Backup of uart_can.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103C8 ST STM32F103C8
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; VECT_TAB_FLASH; IAR_ARM_CM3; STM32F10X_MD
  ICCARM.CCDiagSuppress: Pa082, pe191
  ICCARM.CCIncludePath2: .; freertos\include; freertos\portable\IAR\ARM_CM3; drv; lib\STM32F10x_StdPeriph_Driver\inc; lib\CMSIS\CM3\DeviceSupport\ST\STM32F10x; lib\CMSIS\CM3\CoreSupport; $TOOLKIT_DIR$\CMSIS\Core\Include; lib\ring_buffer
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: .
  OBJCOPY.OOCOutputFile: RTOSDemo.srec
  ILINK.IlinkOutputFile: RTOSDemo.out
  ILINK.IlinkIcfFile: STM32F10x_FLASH.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group drv
    drv/: board.c can.c serial.c
  group FreeRTOS
    freertos/portable/MemMang/: heap_2.c
    freertos/: list.c queue.c tasks.c
    freertos/portable/IAR/ARM_CM3/: port.c portasm.s
  group src
    ./: main.c my_misc.c slc.c stm32f10x_it.c
  group ST Library
    lib/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_can.c stm32f10x_dma.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c
  group ST Library/ring_buffer
    lib/ring_buffer/: ring_buffer.c
  group System files
    lib/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/iar/: startup_stm32f10x_md.s
    ./: stm32f10x_vector.c system_stm32f10x.c
