# IAR project stm32_eth.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F217VG ST STM32F217VG
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER
  ICCARM.CCIncludePath2: system; sources; ; ..\common\libraries\CMSIS\Include; ..\common\startup; ..\common\freertos\source\inc; inc; ..\common\lwip_v1.3.2\src\include; inc; ..\common\lwip_v1.3.2\src\include\ipv4; ..\common\libraries\STM32F2xx_StdPeriph_Driver; ..\common\libraries\STM32F2xx_StdPeriph_Driver\inc; ..\common\freertos\source\port\ARM_CM3; sources\BSP; ..\common\libraries\STM32F2x7_ETH_Driver\inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: inc
  OBJCOPY.OOCOutputFile: te_stm32f207.hex
  ILINK.IlinkOutputFile: c.out
  ILINK.IlinkIcfFile: stm32f2xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: c.srec
configuration F217_debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; FreeRTOS
  ICCARM.CCIncludePath2: system; sources; ; ..\common\libraries\CMSIS\Include; ..\common\startup; ..\common\freertos\source\inc; inc; ..\common\lwip_v1.3.2\src\include; inc; ..\common\lwip_v1.3.2\src\include\ipv4; ..\common\libraries\STM32F2xx_StdPeriph_Driver; ..\common\libraries\STM32F2xx_StdPeriph_Driver\inc; ..\common\freertos\source\port\ARM_CM3; sources\BSP; ..\common\libraries\STM32F2x7_ETH_Driver\inc; ..\common\lwip_v1.3.2\src\include\lwip
  group (top)
    ./: main.c
  group BSP
    sources/: stm32f2x7_eth_bsp.c
  group dbg
    sources/dbg/: uart_dbg.c
  group freertos
    ../common/freertos/source/port/MemMang/: heap_2.c
    ../common/freertos/source/: list.c queue.c tasks.c timers.c
    ../common/freertos/source/port/ARM_CM3/: port.c portasm.s
  group library/src
    ../common/libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_dac.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_rtc.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c
    ../common/libraries/STM32F2xx_StdPeriph_Driver/src/: misc.c stm32f2xx_can.c stm32f2xx_dma.c stm32f2xx_exti.c stm32f2xx_gpio.c stm32f2xx_rcc.c stm32f2xx_rtc.c stm32f2xx_spi.c stm32f2xx_syscfg.c stm32f2xx_tim.c stm32f2xx_usart.c
  group library/src/eth
    ../common/libraries/STM32F2x7_ETH_Driver/src/: stm32f2x7_eth.c
    ../common/libraries/STM32F4x7_ETH_Driver/src/: stm32f4x7_eth.c
  group lwip
    ../common/lwip_v1.3.2/port/STM32F4x7/FreeRTOS/: ethernetif.c
    ../common/lwip_v1.3.2/port/STM32F2x7/FreeRTOS/: ethernetif.c
  group lwip/api
    ../common/lwip_v1.3.2/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group lwip/core
    ../common/lwip_v1.3.2/src/core/: dhcp.c dns.c init.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c udp.c
  group lwip/core/ipv4
    ../common/lwip_v1.3.2/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
  group lwip/netif
    ../common/lwip_v1.3.2/src/netif/: etharp.c
  group sources
    sources/: netconf.c retarget.c snail_spd_brd.c stm32f2xx_it.c sys_arch.c udpecho.c
  group system
    sources/: startup_stm32f2xx.s system_stm32f2xx.c
