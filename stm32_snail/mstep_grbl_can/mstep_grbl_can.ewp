# IAR project mstep_grbl_can.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F205RE ST STM32F205RE
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: VECT_TAB_FLASH; IAR_ARM_CM3; USEUSB; MSTEP_BRD; EMW3162
  ICCARM.CCDiagSuppress: Pa082, pe191
  ICCARM.CCIncludePath2: .; src\board; ..\..\common\freertos\source\inc; src\inc; ..\..\common\freertos\source\port\ARM_CM3; ..\common_stm32\libraries\STM32F2xx_StdPeriph_Driver\inc; ..\common_stm32\libraries\STM32F2xx_StdPeriph_Driver; ..\..\common\dbg; ..\common_stm32\usb\cdc_vcp; ..\common_stm32\usb\drv\inc; ..\common_stm32\usb\core\inc; ..\common_stm32\usb\inc; ..\..\common\can; ..\common_stm32\grbl
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: .; src; src\inc
  OBJCOPY.OOCOutputFile: RTOSDemo.srec
  ILINK.IlinkOutputFile: RTOSDemo.out
  ILINK.IlinkIcfFile: mstep_rtos.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration mstep_debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: VECT_TAB_FLASH; IAR_ARM_CM3; MSTEP_BRD
  ICCARM.CCIncludePath2: .; src\board; ..\common\freertos\source\inc; src\inc; ..\common\freertos\source\port\ARM_CM3; ..\common\libraries\inc; ..\common\libraries; ..\common\dbg; ..\common\libraries\STM32F2xx_StdPeriph_Driver\inc; ..\common\libraries\STM32F2xx_StdPeriph_Driver
configuration step_debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: VECT_TAB_FLASH; IAR_ARM_CM3; USEUSB; STEP_BRD
  ICCARM.CCIncludePath2: .; src\board; ..\common\freertos\source\inc; src\inc; ..\common\freertos\source\port\ARM_CM3; ..\common\libraries\STM32F2xx_StdPeriph_Driver\inc; ..\common\libraries\STM32F2xx_StdPeriph_Driver; ..\common\dbg
configuration step_x_dbg (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: VECT_TAB_FLASH; IAR_ARM_CM3; STEP_BRD; STEP_X
  ICCARM.CCIncludePath2: as above
  group Board
    src/: main.c motor_tsk.c my_misc.c retarget.c serial.c timertest.c
    src/board/: mstep_board.c step_board.c zzzz.c
  group dbg
    ../../common/dbg/: printk1.c
  group drv
    src/drv/: can_drv.c
  group FreeRTOS
    ../../common/freertos/source/port/MemMang/: heap_2.c
    ../../common/freertos/source/: list.c queue.c tasks.c
    ../../common/freertos/source/port/ARM_CM3/: port.c portasm.s portmacro.h
  group grbl
    ../common_stm32/grbl/: gcode.c grbl_init.c grbl_limits.c jog.c nuts_bolts.c planner.c protocol.c report.c system.c
    src/: grbl_tsk.c
  group ST Library
    ../common_stm32/libraries/STM32F2xx_StdPeriph_Driver/src/: misc.c stm32f2xx_can.c stm32f2xx_flash.c stm32f2xx_gpio.c stm32f2xx_rcc.c stm32f2xx_spi.c stm32f2xx_syscfg.c stm32f2xx_tim.c stm32f2xx_usart.c
    ../common_stm32/libraries/STM32F2xx_StdPeriph_Driver/: system_stm32f2xx.c
  group startup
    ../common_stm32/startup/: startup_stm32f2xx.s stm32f2xx_it.c
  group usb
    ../common_stm32/usb/: usb_bsp.c usb_thr.c usbd_desc.c usbd_usr.c
  group usb/cdc_vcp
    ../common_stm32/usb/cdc_vcp/: usbd_cdc_vcp.c usbd_cdc_vcp_core.c
  group usb/core
    ../common_stm32/usb/core/src/: usbd_core.c usbd_ioreq.c usbd_req.c
  group usb/drv
    ../common_stm32/usb/drv/src/: usb_core.c usb_dcd.c usb_dcd_int.c
