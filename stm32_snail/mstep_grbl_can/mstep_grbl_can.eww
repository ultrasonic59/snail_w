<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\mstep_grbl_can_threadx.ewp</path>
    </project>
    <batchBuild>
        <batchDefinition>
            <name>mstep_gbrl_can_dbg</name>
        </batchDefinition>
    </batchBuild>
</workspace>
