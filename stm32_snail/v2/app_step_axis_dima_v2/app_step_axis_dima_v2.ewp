# IAR project app_step_axis_dima_v2.ewp, settings and files
configuration app_step_x_dbg (ARM, debug)
  General.OGChipSelectEditMenu: STM32F205RB ST STM32F205RB
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: VECT_TAB_FLASH; IAR_ARM_CM3; DIMA_BRD; STEP_X; STM32F205xx
  ICCARM.CCDiagSuppress: Pa082, pe191
  ICCARM.CCIncludePath2: .; src\board; src\inc; ..\..\common\freertos\source\inc; ..\..\common\freertos\source\port\ARM_CM3; ..\common_stm32\board; ..\common_stm32\libraries\STM32F2xx_StdPeriph_Driver\inc; ..\common_stm32\libraries\STM32F2xx_StdPeriph_Driver; ..\common_stm32\my_misc; ..\..\common\can; ..\..\common\dbg; ..\common_stm32\libraries\eeprom_emul; ..\common_stm32\can; ..\common_stm32\i2c
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: .; src; src\inc
  OBJCOPY.OOCOutputFile: axis_x.hex
  ILINK.IlinkOutputFile: app_step_x_dbg.out
  ILINK.IlinkIcfFile: app_step_rtos.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration app_step_z_dbg (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: VECT_TAB_FLASH; IAR_ARM_CM3; DIMA_BRD; STEP_Z; STM32F205xx
  ICCARM.CCIncludePath2: .; src\board; src\inc; ..\..\common\freertos\source\inc; ..\..\common\freertos\source\port\ARM_CM3; ..\common_stm32\board; ..\common_stm32\libraries\STM32F2xx_StdPeriph_Driver\inc; ..\common_stm32\libraries\STM32F2xx_StdPeriph_Driver; ..\common_stm32\my_misc; ..\..\common\can; ..\..\common\dbg; ..\common_stm32\libraries\eeprom_emul; ..\common_stm32\can
  OBJCOPY.OOCOutputFile: axis_z.hex
  ILINK.IlinkOutputFile: app_step_z_dbg.out
configuration app_step_y_dbg (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: VECT_TAB_FLASH; IAR_ARM_CM3; DIMA_BRD; STEP_Y; STM32F205xx
  ICCARM.CCIncludePath2: as above
  OBJCOPY.OOCOutputFile: axis_y.hex
  ILINK.IlinkOutputFile: app_step_y_dbg.out
configuration app_step_v2_x_dbg (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F205RC ST STM32F205RC
  ICCARM.CCDefines: VECT_TAB_FLASH; IAR_ARM_CM3; DIMA_BRD_V2; STEP_X; STM32F205xx
  ILINK.IlinkOutputFile: app_step_v2_x_dbg.out
  group (top)
    src/: can_thr.c
  group Board
    src/: app_main.c motor_tsk.c retarget.c
    ../common_stm32/board/: dima_board_v2.c dima_board_v2.h zzzz.c
    ../common_stm32/my_misc/: my_misc.c
    src/board/: step_timer.c
  group dbg
    ../../common/dbg/: printk1.c
  group drv
    src/: app_can_cmds.c
    ../common_stm32/can/: can_drv.c
    ../common_stm32/i2c/: i2c.c
  group FreeRTOS
    ../../common/freertos/source/port/MemMang/: heap_2.c
    ../../common/freertos/source/: list.c queue.c tasks.c
    ../../common/freertos/source/port/ARM_CM3/: port.c portasm.s
  group ST Library
    src/: app_sys_stm32f2xx.c
    ../common_stm32/libraries/STM32F2xx_StdPeriph_Driver/src/: misc.c stm32f2xx_can.c stm32f2xx_flash.c stm32f2xx_gpio.c stm32f2xx_i2c.c stm32f2xx_rcc.c stm32f2xx_spi.c stm32f2xx_tim.c stm32f2xx_usart.c
  group startup
    ../common_stm32/startup/: startup_stm32f2xx.s stm32f2xx_it.c
