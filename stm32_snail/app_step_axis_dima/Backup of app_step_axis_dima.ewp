# IAR project Backup of app_step_axis_dima.ewp, settings and files
configuration app_step_x_dbg (ARM, debug)
  General.OGChipSelectEditMenu: STM32F205RB ST STM32F205RB
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: VECT_TAB_FLASH; IAR_ARM_CM3; DIMA_BRD; STEP_X; STM32F205xx
  ICCARM.CCDiagSuppress: Pa082, pe191
  ICCARM.CCIncludePath2: .; src\board; ..\common\freertos\source\inc; src\inc; ..\common\freertos\source\port\ARM_CM3; ..\common\libraries\STM32F2xx_StdPeriph_Driver\inc; ..\common\libraries\STM32F2xx_StdPeriph_Driver; ..\common\dbg; ..\common\usb\drv\inc; ..\common\board; ..\common\my_grbl; ..\common\can; ..\common\my_misc; ..\common\libraries\eeprom_emul
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: .; src; src\inc
  OBJCOPY.OOCOutputFile: axis_x.hex
  ILINK.IlinkOutputFile: app_step_x_dbg.out
  ILINK.IlinkIcfFile: app_step_rtos.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    src/: can_thr.c
    ../common/libraries/eeprom_emul/: emul_eeprom.c
  group Board
    src/: app_main.c motor_tsk.c retarget.c
    ../common/board/: dima_board.c zzzz.c
    ../common/my_misc/: my_misc.c
    src/board/: step_timer.c
  group dbg
    ../common/dbg/: printk1.c
  group drv
    src/: app_can_cmds.c
    ../common/can/: can_drv.c
  group FreeRTOS
    ../common/freertos/source/port/MemMang/: heap_2.c
    ../common/freertos/source/: list.c queue.c tasks.c
    ../common/freertos/source/port/ARM_CM3/: port.c portasm.s
  group ST Library
    src/: app_sys_stm32f2xx.c
    ../common/libraries/STM32F2xx_StdPeriph_Driver/src/: misc.c stm32f2xx_can.c stm32f2xx_flash.c stm32f2xx_gpio.c stm32f2xx_rcc.c stm32f2xx_spi.c stm32f2xx_tim.c stm32f2xx_usart.c
  group startup
    ../common/startup/: startup_stm32f2xx.s stm32f2xx_it.c
