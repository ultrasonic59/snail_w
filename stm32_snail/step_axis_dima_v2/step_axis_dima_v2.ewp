# IAR project step_axis_dima_v2.ewp, settings and files
configuration step_x_dima_v2 (ARM, debug)
  General.OGChipSelectEditMenu: STM32F205RB ST STM32F205RB
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: VECT_TAB_FLASH; IAR_ARM_CM3; DIMA_BRD_V2; STEP_X; STM32F205xx
  ICCARM.CCDiagSuppress: Pa082, pe191
  ICCARM.CCIncludePath2: .; src\board; src\inc; ..\common\usb\drv\inc; ..\common\board; ..\common\my_grbl; ..\common\can; ..\..\common\freertos\source\inc; ..\..\common\freertos\source\port\ARM_CM3; ..\common_stm32\libraries\STM32F2xx_StdPeriph_Driver; ..\common_stm32\libraries\STM32F2xx_StdPeriph_Driver\inc; ..\common_stm32\board; ..\..\common\can; ..\..\common\dbg
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: .; src; src\inc
  OBJCOPY.OOCOutputFile: step_axis_dima.srec
  ILINK.IlinkOutputFile: step_axis_x_dima_v2.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    src/: can_thr.c
  group Board
    ../common_stm32/board/: dima_board_v2.c dima_board_v2.h
    src/: main.c motor_tsk.c my_misc.c retarget.c
    src/board/: step_timer.c zzzz.c
  group dbg
    ../../common/dbg/: printk1.c
  group drv
    src/: app_can_cmds.c
    ../common_stm32/can/: can_drv.c
  group FreeRTOS
    ../../common/freertos/source/port/MemMang/: heap_2.c
    ../../common/freertos/source/: list.c queue.c tasks.c
    ../../common/freertos/source/port/ARM_CM3/: port.c portasm.s
  group gbrl
    src/grbl/: coolant_control.c eeprom.c gbrl_serial.c gbrl_thr.c gcode.c jog.c limits.c motion_control.c nuts_bolts.c planner.c print.c probe.c protocol.c report.c settings.c spindle_control.c system.c
    ../common/grbl/: stepper.c
    src/: system_stm32f10x.c
  group lib
    ../common_stm32/libraries/eeprom_emul/: emul_eeprom.c
  group ST Library
    ../common_stm32/libraries/STM32F2xx_StdPeriph_Driver/src/: misc.c stm32f2xx_can.c stm32f2xx_flash.c stm32f2xx_gpio.c stm32f2xx_rcc.c stm32f2xx_spi.c stm32f2xx_tim.c stm32f2xx_usart.c
    ../common_stm32/libraries/STM32F2xx_StdPeriph_Driver/: system_stm32f2xx.c
  group startup
    ../common_stm32/startup/: startup_stm32f2xx.s stm32f2xx_it.c
  group usb
    src/usb/: hw_config.c usb_desc.c usb_endp.c usb_istr.c usb_prop.c usb_pwr.c
    src/stm_usb_fs_lib/src/: usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c usb_sil.c
