# IAR project snail_boot.ewp, settings and files
configuration 3165_boot (ARM, debug)
  General.OGChipSelectEditMenu: STM32F411CE ST STM32F411CE
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; USE_rook_boot; EMW3165; STM32F411xE; BOOTER=1
  ICCARM.CCIncludePath2: ..\inc\; ..\src\drv; ..\..\include; ..\..\rook_brd; ..\src\drv; ..\..\..\common\WICED-SDK\WICED\platform\ARM_CM4; ..\..\..\common\WICED-SDK\WICED\platform\ARM_CM4\CMSIS; ..\..\inc; ..\..\..\common\WICED-SDK\platforms\EMW3165; ..\..\..\common\WICED-SDK\WICED\platform\MCU\STM32F4xx\peripherals\libraries; D:\proj\velograph\rook\arm_new\common\WICED-SDK\WICED\platform\MCU\STM32F4xx\peripherals\libraries\inc; ..\..\..\common\include; ..\..\..\common\fs\elmfat; ..\..\..\common\WICED-SDK\WICED\platform\MCU\STM32F4xx\peripherals\libraries\inc; ..\..\..\common\include; ..\..\..\..\arm_cur\common\include; ..\..\..\common\src\drv
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Project.srec
  ILINK.IlinkOutputFile: Project.elf
  ILINK.IlinkIcfFile: stm32f2xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration snail_boot (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F207ZG ST STM32F207ZG
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 38
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F2XX; IS_BOOTER
  ICCARM.CCIncludePath2: ..\..\common\libraries\STM32F2xx_StdPeriph_Driver\inc; ..\..\common\libraries\STM32F2xx_StdPeriph_Driver; $TOOLKIT_DIR$\CMSIS\Core\Include; ..\..\common\board; ..\inc; ..\..\common\dbg
  ILINK.IlinkOutputFile: Project.out
  group CMSIS
    ../../common/libraries/STM32F2xx_StdPeriph_Driver/: system_stm32f2xx.c
    ../../../common/WICED-SDK/WICED/platform/MCU/STM32F4xx/peripherals/libraries/: system_stm32f4xx.c
  group dbg
    ../src/dbg/: printk1.c
  group EWARM
    ../src/: startup_stm32f2xx.s startup_stm32f4xx.s
  group lib/STM32F2xx_StdPeriph_Driver
    ../../common/libraries/STM32F2xx_StdPeriph_Driver/src/: misc.c stm32f2xx_exti.c stm32f2xx_flash.c stm32f2xx_gpio.c stm32f2xx_rcc.c stm32f2xx_spi.c stm32f2xx_syscfg.c stm32f2xx_usart.c
  group lib/stm32f4xx_stdper
    ../../../common/WICED-SDK/WICED/platform/MCU/STM32F4xx/peripherals/libraries/src/: misc.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_usart.c
  group usb
    ../../usb/: usb_bsp.c usbd_desc.c usbd_usr.c
  group usb/class
    ../../usb/Class/hid/src/: usbd_hid_core.c
  group usb/core
    ../../usb/core/src/: usbd_core.c usbd_ioreq.c usbd_req.c
  group usb/otg_drv
    ../../usb/otg_drv/src/: usb_core.c usb_dcd.c usb_dcd_int.c
  group User
    ../src/: flash_if.c main.c stm32f2xx_it.c stm32f4xx_it.c
    ../../../common/src/: my_misc.c
    ../../common/board/: usb_can_board.c
