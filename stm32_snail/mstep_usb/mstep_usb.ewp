# IAR project mstep_usb.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F205RE ST STM32F205RE
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: VECT_TAB_FLASH; IAR_ARM_CM3; USEUSB
  ICCARM.CCDiagSuppress: Pa082, pe191
  ICCARM.CCIncludePath2: .; src\board; ..\common\freertos\source\inc; src\inc; ..\common\freertos\source\port\ARM_CM3; ..\common\libraries\inc; ..\common\libraries; ..\common\dbg
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: .; src; src\inc
  OBJCOPY.OOCOutputFile: RTOSDemo.srec
  ILINK.IlinkOutputFile: RTOSDemo.out
  ILINK.IlinkIcfFile: mstep_rtos.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration mstep_debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: VECT_TAB_FLASH; IAR_ARM_CM3; USEUSB; MSTEP_BRD
configuration step_debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: VECT_TAB_FLASH; IAR_ARM_CM3; USEUSB; STEP_BRD
  ICCARM.CCIncludePath2: .; src\board; ..\common\freertos\source\inc; src\inc; ..\common\freertos\source\port\ARM_CM3; ..\common\libraries\STM32F2xx_StdPeriph_Driver\inc; ..\common\libraries\STM32F2xx_StdPeriph_Driver; ..\common\dbg
configuration usb_can (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: VECT_TAB_FLASH; IAR_ARM_CM3; USEUSB; MSTEP_BRD; STM32F205xx; USE_USB_OTG_FS
  ICCARM.CCIncludePath2: .; src\board; ..\common\freertos\source\inc; src\inc; ..\common\freertos\source\port\ARM_CM3; ..\common\libraries\inc; ..\common\libraries; ..\common\dbg; ..\common\libraries\STM32F2xx_StdPeriph_Driver\inc; ..\common\libraries\STM32F2xx_StdPeriph_Driver; ..\common\usb\core\inc; ..\common\usb\drv\inc; ..\common\usb; ..\common\usb\inc; ..\common\hdlc; ..\common\usb\cdc; src\tinyusb
  group Board
    src/: can.c main.c pc_interf.c serial.c timertest.c
    src/board/: mstep_board.c step_board.c usb_can_board.c zzzz.c
  group dbg
    src/: retarget.c
  group FreeRTOS
    ../common/freertos/source/port/MemMang/: heap_2.c
    ../common/freertos/source/: list.c queue.c tasks.c
    ../common/freertos/source/port/ARM_CM3/: port.c portasm.s
  group gbrl
    src/grbl/: coolant_control.c eeprom.c gbrl_serial.c gbrl_thr.c gcode.c jog.c limits.c motion_control.c nuts_bolts.c planner.c print.c probe.c protocol.c report.c settings.c spindle_control.c stepper.c system.c
    src/: system_stm32f10x.c
  group hdlc
    ../common/hdlc/: fcs16.c hdlc1.c
  group ST Library
    ../common/libraries/STM32F2xx_StdPeriph_Driver/src/: misc.c stm32f2xx_can.c stm32f2xx_flash.c stm32f2xx_gpio.c stm32f2xx_rcc.c stm32f2xx_spi.c stm32f2xx_tim.c stm32f2xx_usart.c
    ../common/libraries/STM32F2xx_StdPeriph_Driver/: system_stm32f2xx.c
  group startup
    ../common/startup/: startup_stm32f2xx.s stm32f2xx_it.c
  group tinyusb
    src/tinyusb/: tusb.c usb_descriptors.c
    src/tinyusb/common/: tusb_fifo.c
  group tinyusb/cdc
    src/tinyusb/class/cdc/: cdc_device.c
  group tinyusb/device
    src/tinyusb/device/: usbd.c usbd_control.c
  group tinyusb/st
    src/tinyusb/portable/st/synopsys/: dcd_synopsys.c
  group usb
    ../common/usb/: usb_bsp.c usb_thr.c usbd_desc.c usbd_usr.c
  group usb/cdc
    ../common/usb/cdc/: usbd_cdc_core.c usbd_cdc_vcp.c
  group usb/cdc_vcp
    ../common/usb/cdc_vcp/: usbd_cdc_vcp.c usbd_cdc_vcp_core.c
  group usb/core
    ../common/usb/core/src/: usbd_core.c usbd_ioreq.c usbd_req.c
  group usb/drv
    ../common/usb/drv/src/: usb_core.c usb_dcd.c usb_dcd_int.c
