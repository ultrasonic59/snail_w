# IAR project Backup of usb_can_dima.ewp, settings and files
configuration usb_can (ARM, debug)
  General.OGChipSelectEditMenu: STM32F205RE ST STM32F205RE
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: VECT_TAB_FLASH; IAR_ARM_CM3; USEUSB; MSTEP_BRD; USE_USB_OTG_FS; STM32F205xx
  ICCARM.CCDiagSuppress: Pa082, pe191
  ICCARM.CCIncludePath2: .; src\board; ..\common\freertos\source\inc; src\inc; ..\common\freertos\source\port\ARM_CM3; ..\common\libraries\inc; ..\common\libraries; ..\common\dbg; ..\common\libraries\STM32F2xx_StdPeriph_Driver\inc; ..\common\libraries\STM32F2xx_StdPeriph_Driver; ..\common\usb\core\inc; ..\common\usb\drv\inc; ..\common\usb; ..\common\usb\inc; ..\common\hdlc; ..\common\usb\cdc; src\my_grbl
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: .; src; src\inc
  OBJCOPY.OOCOutputFile: RTOSDemo.srec
  ILINK.IlinkOutputFile: RTOSDemo.out
  ILINK.IlinkIcfFile: mstep_rtos.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration usb_can_dima (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: VECT_TAB_FLASH; IAR_ARM_CM3; MSTEP_BRD; USE_USB_OTG_FS; STM32F205xx; USEUSB
  ICCARM.CCIncludePath2: .; src\board; ..\common\freertos\source\inc; src\inc; ..\common\freertos\source\port\ARM_CM3; ..\common\libraries\inc; ..\common\libraries; ..\common\dbg; ..\common\libraries\STM32F2xx_StdPeriph_Driver\inc; ..\common\libraries\STM32F2xx_StdPeriph_Driver; ..\common\usb\core\inc; ..\common\usb\drv\inc; ..\common\usb; ..\common\usb\inc; ..\common\hdlc; ..\common\usb\cdc; src\my_grbl; ..\common\libraries\eeprom_emul
  ILINK.IlinkIcfFile: usb_can_dima.icf
  group (top)
    ../common/libraries/eeprom_emul/: emul_eeprom.c
  group Board
    src/: can.c can_thr.c main.c
    src/board/: usb_can_board.c zzzz.c
  group dbg
    ../common/dbg/: printk1.c
    src/: retarget.c
  group FreeRTOS
    ../common/freertos/source/port/MemMang/: heap_2.c
    ../common/freertos/source/: list.c queue.c tasks.c
    ../common/freertos/source/port/ARM_CM3/: port.c portasm.s
  group my_grbl
    src/my_grbl/: can_cmds.c grbl_eeprom.c grbl_print.c grbl_settings.c grbl_system.c grbl_thr.c jog.c limits.c motion_control.c my_gbrl_serial.c my_gcode.c my_protocol.c my_stepper.c nuts_bolts.c planner.c probe.c report.c spindle_control.c stepper.c
  group ST Library
    ../common/libraries/STM32F2xx_StdPeriph_Driver/src/: misc.c stm32f2xx_can.c stm32f2xx_flash.c stm32f2xx_gpio.c stm32f2xx_rcc.c stm32f2xx_spi.c stm32f2xx_tim.c stm32f2xx_usart.c
  group startup
    ../common/startup/: startup_stm32f2xx.s stm32f2xx_it.c
    src/: system_stm32f2xx.c
  group usb
    ../common/usb/: usb_bsp.c usb_thr.c usbd_desc.c usbd_usr.c
  group usb/cdc
    ../common/usb/cdc/: usbd_cdc_core.c usbd_cdc_vcp.c
  group usb/cdc_vcp
    ../common/usb/cdc_vcp/: usbd_cdc_vcp.c usbd_cdc_vcp_core.c
  group usb/core
    ../common/usb/core/src/: usbd_core.c usbd_ioreq.c usbd_req.c
  group usb/drv
    ../common/usb/drv/src/: usb_core.c usb_dcd.c usb_dcd_int.c
