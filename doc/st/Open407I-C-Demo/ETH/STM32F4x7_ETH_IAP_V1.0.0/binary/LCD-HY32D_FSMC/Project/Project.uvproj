# Keil uVision project Project.uvproj, settings and files
target Open407I (ARM-ADS)
  device: STM32F407IG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: Project +hex
  AfterMake: fromelf --bin --output ./output/Projectt.bin ./output/Project.axf
  c define: STM32F4XX, USE_STDPERIPH_DRIVER
  c include: ..\User;..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\Libraries\CMSIS\Include;..\Libraries\CMSIS\Device\ST\STM32F4xx\Include
  memory RVCT4: ROM 0x8010000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ../User/: main.c usart.c config.h stm32f4xx_it.c
    ../User/LCD/: LCD.c AsciiLib.c
  group Startup
    ../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f4xx.s
  group StdPeriph_Driver
    ../Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_usart.c
  group CMSIS
    ../Libraries/CMSIS/Include/: core_cm4.h
    ../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group Readme
    ../User/: readme.txt
